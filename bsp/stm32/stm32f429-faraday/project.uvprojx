# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, RT_USING_ARM_LIBC, STM32F429xx
  c misc: --locale=english
  c include: .;..\..\..\include;applications;.;board;board\CubeMX_Config\Inc;board\ports;board\ports\spi_flash;board\ports\fal_config;board\ports\sdram;board\ports\lcd;board\ports\i2c;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\libraries\HAL_Drivers\drv_flash;packages\fal-latest\inc;packages\gt9147-v1.1.0\inc;packages\LVGL-v8.3-latest\env_support\rt-thread;packages\LVGL-v8.3-latest\src;packages\LVGL-v8.3-latest\src\core;packages\LVGL-v8.3-latest\src\draw;packages\LVGL-v8.3-latest\src\extra;packages\LVGL-v8.3-latest\src\font;packages\LVGL-v8.3-latest\src\hal;packages\LVGL-v8.3-latest\src\misc;packages\LVGL-v8.3-latest\src\widgets;packages\LVGL-v8.3-latest\src\draw\arm2d;packages\LVGL-v8.3-latest\src\draw\nxp;packages\LVGL-v8.3-latest\src\draw\sdl;packages\LVGL-v8.3-latest\src\draw\stm32_dma2d;packages\LVGL-v8.3-latest\src\draw\sw;packages\LVGL-v8.3-latest\src\draw\swm341_dma2d;packages\LVGL-v8.3-latest\src\draw\nxp\pxp;packages\LVGL-v8.3-latest\src\draw\nxp\vglite;packages\LVGL-v8.3-latest\src\extra\layouts;packages\LVGL-v8.3-latest\src\extra\libs;packages\LVGL-v8.3-latest\src\extra\others;packages\LVGL-v8.3-latest\src\extra\themes;packages\LVGL-v8.3-latest\src\extra\widgets;packages\LVGL-v8.3-latest\src\extra\layouts\flex;packages\LVGL-v8.3-latest\src\extra\layouts\grid;packages\LVGL-v8.3-latest\src\extra\libs\bmp;packages\LVGL-v8.3-latest\src\extra\libs\ffmpeg;packages\LVGL-v8.3-latest\src\extra\libs\freetype;packages\LVGL-v8.3-latest\src\extra\libs\fsdrv;packages\LVGL-v8.3-latest\src\extra\libs\gif;packages\LVGL-v8.3-latest\src\extra\libs\png;packages\LVGL-v8.3-latest\src\extra\libs\qrcode;packages\LVGL-v8.3-latest\src\extra\libs\rlottie;packages\LVGL-v8.3-latest\src\extra\libs\sjpg;packages\LVGL-v8.3-latest\src\extra\others\fragment;packages\LVGL-v8.3-latest\src\extra\others\gridnav;packages\LVGL-v8.3-latest\src\extra\others\ime;packages\LVGL-v8.3-latest\src\extra\others\imgfont;packages\LVGL-v8.3-latest\src\extra\others\monkey;packages\LVGL-v8.3-latest\src\extra\others\msg;packages\LVGL-v8.3-latest\src\extra\others\snapshot;packages\LVGL-v8.3-latest\src\extra\themes\basic;packages\LVGL-v8.3-latest\src\extra\themes\default;packages\LVGL-v8.3-latest\src\extra\themes\mono;packages\LVGL-v8.3-latest\src\extra\widgets\animimg;packages\LVGL-v8.3-latest\src\extra\widgets\calendar;packages\LVGL-v8.3-latest\src\extra\widgets\chart;packages\LVGL-v8.3-latest\src\extra\widgets\colorwheel;packages\LVGL-v8.3-latest\src\extra\widgets\imgbtn;packages\LVGL-v8.3-latest\src\extra\widgets\keyboard;packages\LVGL-v8.3-latest\src\extra\widgets\led;packages\LVGL-v8.3-latest\src\extra\widgets\list;packages\LVGL-v8.3-latest\src\extra\widgets\menu;packages\LVGL-v8.3-latest\src\extra\widgets\meter;packages\LVGL-v8.3-latest\src\extra\widgets\msgbox;packages\LVGL-v8.3-latest\src\extra\widgets\span;packages\LVGL-v8.3-latest\src\extra\widgets\spinbox;packages\LVGL-v8.3-latest\src\extra\widgets\spinner;packages\LVGL-v8.3-latest\src\extra\widgets\tabview;packages\LVGL-v8.3-latest\src\extra\widgets\tileview;packages\LVGL-v8.3-latest\src\extra\widgets\win;packages\LVGL-v8.3-latest\demos;packages\minIni-v1.2.0\dev;packages\ota_downloader-latest;packages\pcf8574-latest;packages\small_modbus-latest;packages\small_modbus-latest\inc;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\dfs\include;..\..\..\components\dfs\filesystems\devfs;..\..\..\components\dfs\filesystems\elmfat;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\spi\sfud\inc;..\..\..\components\drivers\include;..\..\..\components\drivers\touch;..\..\..\components\drivers\include;..\..\..\components\drivers\usb\usbdevice;..\..\..\components\finsh;..\..\..\components\libc\compilers\armlibc;..\..\..\components\libc\compilers\common;..\..\..\components\utilities\mod_dac;..\..\..\components\utilities\mod_input;..\..\..\components\utilities\mod_para;..\..\..\components\utilities\mod_trans;..\..\..\components\utilities\ui;..\..\..\components\utilities\utils_list;..\..\..\components\utilities\ymodem;..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\libraries\STM32F4xx_HAL\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/ports/spi_flash/: spi_flash_init.c
    board/ports/fal_config/: fal_flash_sfud_port.c fal_filesystem_init.c
    board/ports/i2c/: i2c_port.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_spi.c drv_soft_i2c.c drv_sdram.c drv_lcd.c drv_usbd.c drv_common.c
    ../libraries/HAL_Drivers/drv_flash/: drv_flash_f4.c
  group fal
    packages/fal-latest/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
  group gt9147
    packages/gt9147-v1.1.0/src/: gt9147.c
  group LVGL-port
    packages/LVGL-v8.3-latest/env_support/rt-thread/: lv_port_disp.c lv_port_fs.c lv_port_indev.c lv_rt_thread_port.c
  group LVGL
    packages/LVGL-v8.3-latest/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    packages/LVGL-v8.3-latest/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    packages/LVGL-v8.3-latest/src/extra/: lv_extra.c
    packages/LVGL-v8.3-latest/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    packages/LVGL-v8.3-latest/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    packages/LVGL-v8.3-latest/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    packages/LVGL-v8.3-latest/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    packages/LVGL-v8.3-latest/src/draw/arm2d/: lv_gpu_arm2d.c
    packages/LVGL-v8.3-latest/src/draw/nxp/: lv_gpu_nxp.c
    packages/LVGL-v8.3-latest/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    packages/LVGL-v8.3-latest/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    packages/LVGL-v8.3-latest/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    packages/LVGL-v8.3-latest/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    packages/LVGL-v8.3-latest/src/draw/nxp/pxp/: lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    packages/LVGL-v8.3-latest/src/draw/nxp/vglite/: lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_rect.c lv_gpu_nxp_vglite.c
    packages/LVGL-v8.3-latest/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-v8.3-latest/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-v8.3-latest/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-v8.3-latest/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-v8.3-latest/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-v8.3-latest/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    packages/LVGL-v8.3-latest/src/extra/libs/gif/: gifdec.c lv_gif.c
    packages/LVGL-v8.3-latest/src/extra/libs/png/: lodepng.c lv_png.c
    packages/LVGL-v8.3-latest/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    packages/LVGL-v8.3-latest/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v8.3-latest/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    packages/LVGL-v8.3-latest/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    packages/LVGL-v8.3-latest/src/extra/others/gridnav/: lv_gridnav.c
    packages/LVGL-v8.3-latest/src/extra/others/ime/: lv_ime_pinyin.c
    packages/LVGL-v8.3-latest/src/extra/others/imgfont/: lv_imgfont.c
    packages/LVGL-v8.3-latest/src/extra/others/monkey/: lv_monkey.c
    packages/LVGL-v8.3-latest/src/extra/others/msg/: lv_msg.c
    packages/LVGL-v8.3-latest/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-v8.3-latest/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-v8.3-latest/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-v8.3-latest/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-v8.3-latest/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-v8.3-latest/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    packages/LVGL-v8.3-latest/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-v8.3-latest/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-v8.3-latest/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-v8.3-latest/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v8.3-latest/src/extra/widgets/led/: lv_led.c
    packages/LVGL-v8.3-latest/src/extra/widgets/list/: lv_list.c
    packages/LVGL-v8.3-latest/src/extra/widgets/menu/: lv_menu.c
    packages/LVGL-v8.3-latest/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-v8.3-latest/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v8.3-latest/src/extra/widgets/span/: lv_span.c
    packages/LVGL-v8.3-latest/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v8.3-latest/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-v8.3-latest/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-v8.3-latest/src/extra/widgets/tileview/: lv_tileview.c
    packages/LVGL-v8.3-latest/src/extra/widgets/win/: lv_win.c
  group minIni
    packages/minIni-v1.2.0/dev/: minIni.c
  group ota_downloader
    packages/ota_downloader-latest/src/: ymodem_ota.c
  group pcf8574
    packages/pcf8574-latest/: pcf8574.c
  group small_modbus
    packages/small_modbus-latest/src/: small_modbus_base.c small_modbus_port_rtthread.c small_modbus_rtu.c small_modbus_utils.c
  group cpu
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group Filesystem
    ../../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../../components/dfs/filesystems/devfs/: devfs.c
    ../../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../../components/dfs/filesystems/elmfat/option/: ccsbcs.c
  group DeviceDrivers
    ../../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../components/drivers/misc/: pin.c input_ts.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c spi_ad5541.c spi_flash_sfud.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Touch
    ../../../components/drivers/touch/: touch.c
  group rt_usbd
    ../../../components/drivers/usb/usbdevice/core/: core.c usbdevice.c
    ../../../components/drivers/usb/usbdevice/class/: mstorage.c
  group finsh
    ../../../components/finsh/: shell.c cmd.c msh.c msh_file.c
  group libc
    ../../../components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c
    ../../../components/libc/compilers/common/: time.c
  group mod_dac
    ../../../components/utilities/mod_dac/: mod_dac.c
  group mod_input
    ../../../components/utilities/mod_input/: mod_input.c
  group mod_para
    ../../../components/utilities/mod_para/: mod_para.c
  group mod_trans
    ../../../components/utilities/mod_trans/: mod_trans.c
  group ui
    ../../../components/utilities/ui/: font_Atlantico_22.c font_bahnschrift_13.c font_bahnschrift_17.c font_bahnschrift_35.c font_ch_16.c font_symbol_20.c font_symbol_32.c font_tw_15.c ui_bar.c ui_boot.c ui_login.c ui_main.c ui_param.c ui_setting.c ui_summary.c ui_utils.c
  group utils_list
    ../../../components/utilities/utils_list/: utils_list.c
  group Utilities
    ../../../components/utilities/ymodem/: ymodem.c
  group STM32_HAL
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_qspi.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_ll_dma2d.c stm32f4xx_hal_dsi.c
